# Autodesk Inventor part: 5MBM24-2-3-internetui
## iProperties
Created: 2010-01
Part Number: 5MBM24-2-3-internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
